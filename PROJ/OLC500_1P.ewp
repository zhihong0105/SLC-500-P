# IAR project OLC500_1P.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; ..\FWLIB\inc; ..\USER\include
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: OLC500_1P.hex
  ILINK.IlinkOutputFile: OLC500_1P.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: SLC-500-P12-180424_Release.hex
  group USER
    ../: Description.h
    ../USER/source/: main.c PID.c stm8s_it.c System_Initialize.c TaskHandle.c TemperatureNTC.c
    ../USER/include/: TemperatureNTC.h
