<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>FWLIB</name>
  </group>
  <group>
    <name>USER</name>
    <file>
      <name>$PROJ_DIR$\..\Description.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\USER\source\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\USER\source\PID.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\USER\source\stm8s_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\USER\source\System_Initialize.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\USER\source\TaskHandle.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\USER\source\TemperatureNTC.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\USER\include\TemperatureNTC.h</name>
    </file>
  </group>
</project>


